# Keil uVision project WindSpeedDetectingSystem.uvprojx, settings and files
target ZX (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: WindSpeedDetectingSystem +hex
  AfterMake: fromelf --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Src;..\Src\CMSIS\Core;..\Src\CMSIS\Device;..\Src\Hardware\STMFLASH;..\Src\Hardware\GSM;..\Src\Hardware\WindSpeedSensor;..\Src\Hardware\CRC;..\Src\STM32F10x_FWLib\inc;..\Src\System\delay;..\Src\System\sys;..\Src\System\usart;..\Src\System\rtc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../Src/: main.c stm32f10x_it.c
  group Hardware
    ../Src/Hardware/STMFLASH/: stmflash.c
    ../Src/Hardware/WindSpeedSensor/: WindSpeedSensor.c
    ../Src/Hardware/GSM/: GSM.c
    ../Src/Hardware/CRC/: crc.c
  group System
    ../Src/System/delay/: delay.c
    ../Src/System/sys/: sys.c
    ../Src/System/usart/: usart.c
    ../Src/System/rtc/: rtc.c
  group Core
    ../Src/CMSIS/Core/: core_cm3.c
    ../Src/CMSIS/Device/: system_stm32f10x.c
    ../Src/CMSIS/Device/startup/: startup_stm32f10x_hd.s
  group FWLib
    ../Src/STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
